# Repository vilelalabs/SimplePomodoro

File README.md:

# Simple Pomodoro
A simple pomodoro timer written in C with **PIC16F84A**

## How to Use
- When you turn on, LED (rgb) will blink GREEN 3 times on init. The 25 minutes is running!
- after 25 minutes, Led will blink RED, you need to push the button to start the 5 minutes rest timer. The led turns (and stay) blue.
- ater the 5 minutes rest time, LED will blink blue. You need to push the button to restart the pomodoro to the 25 minutes.
## Code
- set fuse bits as in **config.h** file
- set in/out pin in **pins.h** file
- set another \[X\] (for 1st timer) and \[Y\] (for 2nd. timer) in loop at main function:
```c
  tempo(X);       //25 minutes
  focusBeep();
  tempo(Y);       //5 minutes
  restTime();
```
## Schematic, PCB  and 3D view

Schematic                  |  Printed Circuit Board |   3D visualization             
:-------------------------:|:-------------------------:|:-------------------------:
  |     |

## EAGLE design simple_pomodoro.brd

Parts:
BUZZER: F/QMBIII
C1, C2: 47pF; CAP-PTH-2.54
J1: ICSP PICKit3; M_1R06_100MIL-V
J2: KF301-2P; HANDSON_KF301-2P
LED: RGBLED_CA-5MM; LED5MMRGB
R1: 470; 0207/10
R2, R3: 10k; 0207/10
S2: PUSH BUTTON; B3F-40XX-ROUND
U1: PIC16F84A-04/P; DIP254P762X432-18
XTAL: 4MHz; HC49/S

Connections:
BLUE: LED.4 (BLUE), U1.9 (RB3)
BTN: R2.2, S2.1 (S), S2.2 (S1), U1.10 (RB4)
BUZZER: BUZZER.+ (-), U1.11 (RB5)
GND: BUZZER.- (+), C1.2, C2.2, J1.3, J2.1, S2.3, S2.4 (P1), U1.5 (VSS)
GREEN: LED.3 (GREEN), U1.8 (RB2)
MCLR: J1.1, R3.1, U1.4 (~MCLR)
unnamed: J1.5, U1.12 (RB6)
unnamed: J1.4, U1.13 (RB7)
unnamed: LED.2 (VCC), R1.1
RED: LED.1 (RED), U1.7 (RB1)
VCC: J1.2, J2.2, R1.2, R2.1, R3.2, U1.14 (VDD)
XT1: C2.1, U1.16 (OSC1/CLKIN), XTAL.1
XT2: C1.1, U1.15 (OSC2/CLKOUT), XTAL.2

Notes on the sheet:
PGM (LVP) [N.C.]
SIMPLE POMODORO V 1.0
PGC (ICSPCLK)
PGD (ISCPDAT)
VSS (GND)
VDD (Target)
VPP / !MCLR

Board: 2 copper layers, 49.9 x 49.6 mm, 12 parts (0 on the bottom side), 13 nets.

## Code that names these connections

File pins.h:

#ifndef PINS_H
#define	PINS_H

#define LED_R   PORTBbits.RB1   // LED_R
#define LED_G   PORTBbits.RB2   // LED_G
#define LED_B   PORTBbits.RB3   // LED_B

#define BUTTON  PORTBbits.RB4   // Button

#define BUZZER  PORTBbits.RB5   //Buzzer

#endif	/* PINS_H */

## Commit log

2021-09-06 Better comments and code view
2021-09-06 Update README.md
    correct mispelling
2021-09-06 schematic upload
2021-09-06 schematci image added.
2021-09-07 added pcb (board and 3D)
2021-09-07 uploaded and positioning schematic, pcb and 3D
2021-09-07 eagle files upload
    Updated schematic
    Added eagle project file
    Added board file
2021-09-07 added control when button must work
    Add fews comments and clean code too.
2021-09-07 Added final hex file to PIC upload
2021-09-08 buzzer polarity corrected

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
